# IAR project RadioYuN.ewp, settings and files
configuration STM32F7-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F756xx; USE_HAL_DRIVER; USE_STM32746G_DISCOVERY
  ICCARM.CCIncludePath2: ..\STemWin_Addons; ..\Config; ..\User; ..\STemWin_Addons; ..\Modules\Audio_Player; ..\Modules\Audio_Recorder; ..\Modules\Common; ..\Modules\Vnc_Server; ..\..\..\..\Utilities\Cpu; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32746G-Discovery; ..\..\..\..\Drivers\BSP\Components; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\..\..\..\Middlewares\Third_Party\LwIP\src\include\; ..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4; ..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\Middlewares\Third_Party\LwIP\system\OS; ..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Modules\Audio_Player\Addons\SpiritDSP_Equalizer; ..\Modules\Audio_Player\Addons\SpiritDSP_LoudnessControl
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM32F746G-RadioYuN.hex
  ILINK.IlinkOutputFile: STM32F746G-RadioYuN.out
  ILINK.IlinkIcfFile: stm32f746g.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\inc; ..\STemWin_Addons; ..\Config; ..\User; ..\STemWin_Addons; ..\Modules\Vnc_Server; ..\..\..\..\Utilities\CPU; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32746G-Discovery; ..\..\..\..\Drivers\BSP\Components; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\..\..\..\Middlewares\Third_Party\LwIP\src\include\; ..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4; ..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\Middlewares\Third_Party\LwIP\system\OS; ..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Modules\audio_player\Addons\SpiritDSP_Equalizer; ..\Modules\audio_player\Addons\SpiritDSP_LoudnessControl
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM327x6G-EVAL_Demo.out
  group Application/Config
    ../Config/: ffconf.h FreeRTOSConfig.h GUIConf.h LCDConf.h lwipopts.h stm32f7xx_hal_conf.h usbh_conf.h
  group Application/Modules/Audio/Inc
    ../Modules/Audio_Player/: audio_player_app.h
  group Application/Modules/Audio/Src
    ../Modules/Audio_Player/: audio_player_app.c audio_player_win.c
  group Application/Modules/Audio/Src/Addons
    ../Modules/Audio_Player/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m4.a
    ../Modules/Audio_Player/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m4.a
  group Application/Modules/Audio_Recorder/Inc
    ../Modules/Audio_Recorder/: audio_recorder_app.h
  group Application/Modules/Audio_Recorder/Src
    ../Modules/Audio_Recorder/: audio_recorder_app.c audio_recorder_win.c
  group Application/Modules/Common/Inc
    ../Modules/Common/: audio_if.h
  group Application/Modules/Common/Src
    ../Modules/Common/: audio_if.c
  group Application/Modules/Games
    ../Modules/Games/: games_win.c
  group Application/Modules/Gardening_Control
    ../Modules/Gardening_Control/: gardening_control_win.c
  group Application/Modules/Home_Alarm
    ../Modules/Home_Alarme/: home_alarm_win.c
  group Application/Modules/Sys_Info
    ../Modules/Settings/: settings_win.c
  group Application/Modules/Video_Player
    ../Modules/Video_Player/: video_player_win.c
  group Application/Modules/Vnc_Server/Inc
    ../Modules/Vnc_Server/: ethernetif.h vnc_app.h
  group Application/Modules/Vnc_Server/Src
    ../Modules/Vnc_Server/: ethernetif.c vnc_app.c vnc_server_win.c
  group Application/User/Inc
    ../User/: k_bsp.h k_module.h k_rtc.h k_storage.h main.h stm32f7xx_it.h
  group Application/User/Src
    ../User/: k_bsp.c k_menu.c k_module.c k_rtc.c k_startup.c k_storage.c main.c stm32f7xx_it.c
  group Application/Utilities/Cpu/Inc
    ../../../../Utilities/Cpu/: cpu_utils.h
  group Application/Utilities/Cpu/Src
    ../../../../Utilities/Cpu/: cpu_utils.c
  group Drivers/BSP/Component/Ft5336/Inc
    ../../../../Drivers/BSP/Components/ft5336/: ft5336.h
  group Drivers/BSP/Component/Ft5336/Src
    ../../../../Drivers/BSP/Components/ft5336/: ft5336.c
  group Drivers/BSP/Component/Vm8994/Inc
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.h
  group Drivers/BSP/Component/Vm8994/Src
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32746G_DISCO/Inc
    ../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.h stm32746g_discovery_audio.h stm32746g_discovery_camera.h stm32746g_discovery_eeprom.h stm32746g_discovery_lcd.h stm32746g_discovery_qspi.h stm32746g_discovery_sd.h stm32746g_discovery_sdram.h stm32746g_discovery_ts.h
  group Drivers/BSP/STM32746G_DISCO/Src
    ../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/CMSIS/Device/ST/STM32F7xx/Inc
    ../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include/: stm32f746xx.h stm32f7xx.h system_stm32f7xx.h
  group Drivers/CMSIS/Device/ST/STM32F7xx/Src
    ../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/CMSIS/Device/ST/STM32F7xx/Src/Startup
    ../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
  group Drivers/STM32F4xx_HAL_Drivers/Inc
    ../../../../Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_conf_template.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_usb.h
  group Drivers/STM32F4xx_HAL_Drivers/Src
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/FatFs/Core/Inc
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.h ff.h ff_gen_drv.h integer.h
  group Middlewares/FatFs/Core/Src
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers/Inc
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.h
  group Middlewares/FatFs/Drivers/Src
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS/Inc
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.h
  group Middlewares/FreeRTOS/CMSIS_RTOS/Src
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/Portable/IAR/ARM_CM7/r0p1/Inc
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: portmacro.h
  group Middlewares/FreeRTOS/Portable/IAR/ARM_CM7/r0p1/Src
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/FreeRTOS/Portable/MemMang
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FreeRTOS/Include
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Middlewares/LwIP/Api
    ../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core
    ../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LwIP/Include/Ipv4/Lwip
    ../../../../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group Middlewares/LwIP/Include/Lwip
    ../../../../Middlewares/Third_Party/LwIP/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h lwip_timers.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcp_impl.h tcpip.h udp.h
  group Middlewares/LwIP/Include/Netif
    ../../../../Middlewares/Third_Party/LwIP/src/include/netif/: etharp.h ppp_oe.h slipif.h
  group Middlewares/LwIP/Include/Posix
    ../../../../Middlewares/Third_Party/LwIP/src/include/posix/: netdb.h
  group Middlewares/LwIP/Include/Posix/Sys
    ../../../../Middlewares/Third_Party/LwIP/src/include/posix/sys/: socket.h
  group Middlewares/LwIP/Netif
    ../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
    ../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/STemWin/Config
    ../Config/: GUIConf.c LCDConf.c
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM7_OS_IAR_ot.a
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons/Inc
    ../STemWin_Addons/: STM32746G_Discovery_STemWin_Addons.h
  group Middlewares/STemWin/ST_GUI_Addons/Lib
    ../STemWin_Addons/: STM32746G_Discovery_STemWin_Addons_IAR.a
  group Middlewares/USBH_Library/Class/MSC/Inc
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
  group Middlewares/USBH_Library/Class/MSC/Src
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Middlewares/USBH_Library/Core/Inc
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_def.h usbh_ioreq.h usbh_pipes.h
  group Middlewares/USBH_Library/Core/Src
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
